SUMMARY="dnsmasq configuration"

FILESEXTRAPATHS_prepend = "${THISDIR}/files:"