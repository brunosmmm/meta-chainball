inherit pypi setuptools3
require python-beaker.inc