
inherit pypi setuptools3
require python-pygame.inc