SUMMARY = "Chainball Live Online"
DESCRIPTION = "Publish live results during chainball tournaments"

PR= "r0"
